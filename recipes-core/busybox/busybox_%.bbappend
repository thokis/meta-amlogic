FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append:amlogic = " file://dd.cfg"
